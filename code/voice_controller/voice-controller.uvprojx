# Keil uVision project voice-controller.uvprojx, settings and files
target STM32F051 Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: voice-controller
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c misc: --c99
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Files
    ./: InitDevice.c interrupts.c Oscillator.c DAC084S085.c main.c VCA.c
  group Header Files
    ./: DAC084S085.h Oscillator.h interrupts.h InitDevice.h VCA.h
target STM32F051 RAM (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: voice-controller
  c flags: Optim=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x1000
  memory RVCT9: RAM 0x20001000 size 0x1000
software components: CMSIS:CORE 3.40.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:Startup 2.2.3
